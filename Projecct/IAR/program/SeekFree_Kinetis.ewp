# IAR project SeekFree_Kinetis.ewp, settings and files
configuration MK60DN_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60DN; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option; ..\..\..\Libraries\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: MK60FX; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ILINK.IlinkIcfFile: linker\MK60xX512_15.icf
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_dma.h MK60_gpio.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_systick.h MK60_uart.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_dma.c MK60_gpio.c MK60_pit.c MK60_port.c MK60_systick.c MK60_uart.c
  group seekfree
    ../../../Libraries/seekfree/: SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s startup_MK60F15.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60.c
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/User/: Picture_Process.c
    ../../../Libraries/: version.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
    ../../../Libraries/User/: Picture_Process.h
